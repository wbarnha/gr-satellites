options:
  parameters:
    author: Daniel Estevez
    category: Satellites
    description: FloripaSat-1 decoder
    generate_options: hb
    id: floripasat_1
    output_language: python
    run_options: run
    title: FloripaSat-1 decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''01011101111001100010101001111110'''
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: 0.175*3
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: invert*10
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '8'
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '8'
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {state: disabled}
- name: ccsds_descrambler_0_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: ccsds_descrambler_0_0_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: '8'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: '4'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {state: disabled}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {state: disabled}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '5'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '600'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '5'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '600'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 1k2
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 2k4
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {state: disabled}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {state: disabled}
- name: satellites_floripasat_telemetry_parser_0
  id: satellites_floripasat_telemetry_parser
  parameters: {}
  states: {state: disabled}
- name: satellites_ngham_check_crc_0
  id: satellites_ngham_check_crc
  parameters: {}
  states: {}
- name: satellites_ngham_packet_crop_0
  id: satellites_ngham_packet_crop
  parameters: {}
  states: {}
- name: satellites_ngham_remove_padding_0
  id: satellites_ngham_remove_padding
  parameters: {}
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {state: disabled}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '44885'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: sync_to_pdu_packed_0
  id: sync_to_pdu_packed
  parameters:
    packlen: 255+3
    sync: access_code
    threshold: threshold
  states: {}
- name: sync_to_pdu_packed_0_0
  id: sync_to_pdu_packed
  parameters:
    packlen: 255+3
    sync: access_code
    threshold: threshold
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_tagged_stream_multiply_length_0_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', blocks_tagged_stream_multiply_length_0_0_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0_0_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, ccsds_descrambler_0_0, in]
- [blocks_tagged_stream_to_pdu_0_0, pdus, ccsds_descrambler_0_0_0, in]
- [ccsds_descrambler_0_0, out, satellites_ngham_remove_padding_0, in]
- [ccsds_descrambler_0_0_0, out, satellites_ngham_remove_padding_0, in]
- [digital_binary_slicer_fb_0, '0', sync_to_pdu_packed_0, '0']
- [digital_binary_slicer_fb_0_0, '0', sync_to_pdu_packed_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [low_pass_filter_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [satellites_ngham_check_crc_0, ok, pad_sink_0, in]
- [satellites_ngham_check_crc_0, ok, satellites_print_timestamp_0, in]
- [satellites_ngham_packet_crop_0, rs16, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_ngham_packet_crop_0, rs32, blocks_pdu_to_tagged_stream_0_0, pdus]
- [satellites_ngham_remove_padding_0, out, satellites_ngham_check_crc_0, in]
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print_pdu]
- [satellites_print_timestamp_0, out, satellites_floripasat_telemetry_parser_0, in]
- [satellites_print_timestamp_0, out, satellites_submit_0, in]
- [sync_to_pdu_packed_0, out, satellites_ngham_packet_crop_0, in]
- [sync_to_pdu_packed_0_0, out, satellites_ngham_packet_crop_0, in]

metadata:
  file_format: 1
